## arch/arm64/configs/custom_defconfig
```kconfig
CONFIG_LOCALVERSION="-GhostSP-v2.9-CasCom"
# CONFIG_LOCALVERSION_AUTO is not set
```
